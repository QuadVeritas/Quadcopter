# Keil uVision project uCOS_II.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uCOS_II +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\Ports;.\Cfg\Template;..\uCOS_II;.\Periph;.\Startup;.\Core;.\SystemView\Config;.\SystemView\Sample\uCOS-II;.\SystemView\Sample\uCOS-II\Config;.\SystemView\SEGGER
  asm include: .\Source;.\Ports;.\Cfg\Template;..\uCOS_II;.\Periph;.\Startup;.\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ./Source/: ucos_ii.c os_dbg_r.c
  group Ports
    ./Ports/: os_cpu.c os_cpu_a.asm
  group Cfg
    ./Cfg/Template/: app_hooks.c
  group User
    ./User/: main.c
    ./: tasks.c includes.h interrupts.c ahrs.c ahrs.h
  group Periph
    ./: gy86.c motor.c receiver.c GY86.h bluetooth.c led.c receiver.h mpu6050.c mpu6050.h iic.h gy86time.h gy86time.c iic.c
  group Core
    ./: nvic.c
  group SystemView
    ./SystemView/Sample/uCOS-II/: SEGGER_SYSVIEW_uCOSII.c
    ./SystemView/Sample/uCOS-II/Config/Cortex-M/: SEGGER_SYSVIEW_Config_uCOSII.c
    ./SystemView/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
